# Keil uVision project Morse.uvprojx, settings and files
target Target_1 (6220000::V6.22::ARMCLANG)
  device: MKL05Z32xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.1
  cpu: IRAM(0x1FFFFC00,0x00001000) IROM(0x00000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Morse
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 wLevel=3
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x1ffffc00 size 0x1000
  group Source Group 1
    ./: main.c UART_COMMUNICATION.c UART_COMMUNICATION.h peripherals_.c peripherals_.h
    ../lab1/: frdm_bsp.h
software components: CMSIS:CORE 6.1.0, Device:Startup 1.0.0
